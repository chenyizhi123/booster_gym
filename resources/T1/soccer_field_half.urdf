Commit message: feat:change something

File: resources/T1/soccer_field_half.urdf (robot description, URDF)
Before this commit: robot soccer_field_half, 3 links, 2 joints
Links:
- link field_base: geometry collision box size=12 9 0.01
